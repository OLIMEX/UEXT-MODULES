# IAR project STM32-P103_MOD-3310_Demo.ewp, settings and files
configuration MOD-LCD3310_GPIO (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL; USE_GPIO
  ICCARM.CCIncludePath2: ; ..\Libraries\MOD-LCD3310; ..\Libraries\CMSIS\Core\CM3; ..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\Utilities\STM32_EVAL; ..\Utilities\STM32_EVAL\STM3210B_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IOToggle.srec
  ILINK.IlinkOutputFile: STM3210B-EVAL.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MOD-LCD3310-SPI (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_STM3210B_EVAL; USE_SPI
  group CMSIS
    ../Libraries/CMSIS/Core/CM3/: system_stm32f10x.c
  group MOD-LCD3310
    ../Libraries/MOD-LCD3310/: lcd3310_GPIO.c lcd3310_SPI.c
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c
  group STM32_EVAL
    ../Utilities/STM32_EVAL/: stm32_eval.c
  group User
    ./: main.c stm32f10x_it.c
